# IAR project speed.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2138 NXP LPC2138
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: LPC2000_IAR
  ICCARM.CCDiagSuppress: pe815, pe191, pa082, pe167
  ICCARM.CCIncludePath2: ..\FreeRTOS\Source\portable\iar\LPC2000; ..\FreeRTOS\Demo\common\include; ..\FreeRTOS\Source\include; SrcIAR; $PROJ_DIR$
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: SrcIAR; ..\FreeRTOS\Demo\common\include; ..\FreeRTOS\Source\include; $PROJ_DIR$; ..\FreeRTOS\Source\portable\iar\LPC2000
  ILINK.IlinkOutputFile: rtosdemo.out
  ILINK.IlinkIcfFile: resource\LPC2138.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Bin (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group lcd
    boe/: drv_hd44780.c drv_hd44780_l.c lcd.c
  group pwm
    boe/: pwm.c PWMISR.s79
  group Scheduler Source
    ../FreeRTOS/Source/: list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/IAR/LPC2000/: port.c portasm.s79
  group Speed
    ../FreeRTOS/Source/portable/MemMang/: heap_1.c
    ./: main.c
    serial/: serial.c serialISR.s79
    boe/: speed.c
  group System Files
    SrcIAR/: lpc2xxx_cstartup.s
  group timer1
    boe/: timer1.c timer1ISR.s79
